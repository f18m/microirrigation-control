# IAR project Backup of smpl_link.ewp, settings and files
configuration REMOTE (8051, debug)
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  ICC8051.CCDefines: MRFI_CC1110; MCU_H="ioCC1110.h"; REMOTE=1
  ICC8051.CCDiagSuppress: Pe001,Pa084,Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../source/components\simpliciti\bsp; ../source/components\simpliciti\bsp\drivers; ../source/components\simpliciti\bsp\boards\SRFCCxx10; ../source/components\simpliciti\mrfi; ../source/components\simpliciti\simpliciti\nwk; ../source/components\simpliciti\simpliciti\nwk_applications
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=1110
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc1110F32.xcl
configuration LIME2 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: MRFI_CC1110; MCU_H="ioCC1110.h"; LIME2=1
  ICC8051.CCOptLevel: 3
  group components/bsp
    ../source/components/simpliciti/bsp/: bsp.c bsp.h bsp_macros.h
    ../source/components/simpliciti/bsp/mcus/: bsp_8051_defs.h
    ../source/components/simpliciti/bsp/boards/SRFCCxx10/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
    ../source/components/simpliciti/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
    ../source/components/simpliciti/bsp/drivers/: bsp_buttons.h bsp_leds.h
    ../source/components/simpliciti/bsp/boards/SRFCCxx10/bsp_external/: mrfi_board_defs.h
  group components/bsp/extended
    ../source/apps/: bsp_extended.c bsp_extended.h
  group components/mrfi
    ../source/components/simpliciti/mrfi/: mrfi.c mrfi.h mrfi_defs.h
    ../source/components/simpliciti/mrfi/smartrf/cc1110/: smartrf_CC1110_srfcc1110.h
    ../source/components/simpliciti/mrfi/smartrf/cc2510/: smartrf_cc2510_srfcc2510.h
  group components/mrfi/radios
    ../source/components/simpliciti/mrfi/radios/common/: mrfi_f1f2.c mrfi_f1f2.h
    ../source/components/simpliciti/mrfi/radios/family2/: mrfi_radio.c
  group peer applications/application
    ../source/apps/: hal_cc8051.h hal_defs.h hal_types.h ioCCxx10_bitdef.h lime2.c main.c main.h remote.c
  group peer applications/configuration
    ../source/apps/: smpl_config.dat smpl_nwk_config.dat
